# Keil uVision project Claw Game.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Claw Game
  c flags: Optim=1
  group Source Group 1
    ./: main.c
    C:/Keil/EE319KwareSpring2016/PeriodicTimer0AInts_4C123/: Timer0A.h PLL.h Timer0A.c
    C:/Keil/EE319KwareSpring2016/inc/: tm4c123gh6pm.h
