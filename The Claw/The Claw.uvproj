# Keil uVision project The Claw.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: The Claw
  c flags: Optim=1
  group Source Group 1
    ./: Stepper Motors.c Claw_Main.c
    C:/Keil/EE319KwareSpring2016/inc/: tm4c123gh6pm.h
